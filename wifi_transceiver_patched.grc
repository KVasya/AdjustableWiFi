options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: wifi_transceiver_patched
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "Linear Comb", "STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '2412000000.0'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 2.412e09
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: 6e6
    option2: 11e6
    type: real
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {state: disabled}
- name: rx_if_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: rx_vga_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e06
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["100kHz","5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[0.1e6, 5e6, 10e6, 20e6]'
    type: real
    value: 20e6
  states: {state: disabled}
- name: sensitivity
  id: variable
  parameters:
    value: '.56'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {state: disabled}
- name: tx_vga_gain
  id: variable
  parameters:
    value: '47'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/wifi.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: blocks_message_debug_0_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {state: disabled}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {}
- name: blocks_msgpair_to_var_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: rx_if_gain
  states: {}
- name: blocks_msgpair_to_var_0_1
  id: blocks_msgpair_to_var
  parameters:
    target: samp_rate
  states: {}
- name: blocks_msgpair_to_var_0_2
  id: blocks_msgpair_to_var
  parameters:
    target: rx_vga_gain
  states: {}
- name: blocks_msgpair_to_var_0_2_0
  id: blocks_msgpair_to_var
  parameters:
    target: tx_vga_gain
  states: {}
- name: blocks_msgpair_to_var_0_2_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: sensitivity
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6'
    minoutbuf: '100000'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: freq
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: rx_if_gain
    target: rx_if_gain
  states: {}
- name: blocks_var_to_msg_0_1
  id: blocks_var_to_msg
  parameters:
    msgname: samp_rate
    target: samp_rate
  states: {}
- name: blocks_var_to_msg_0_2
  id: blocks_var_to_msg
  parameters:
    msgname: rx_vga_gain
    target: rx_vga_gain
  states: {}
- name: blocks_var_to_msg_0_2_0
  id: blocks_var_to_msg
  parameters:
    msgname: tx_vga_gain
    target: tx_vga_gain
  states: {}
- name: blocks_var_to_msg_0_2_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: sensitivity
    target: sensitivity
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: '100000'
    pad_front: '10000'
    pad_tail: '10000'
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {state: disabled}
- name: ieee802_11_ether_encap_0
  id: ieee802_11_ether_encap
  parameters:
    debug: 'False'
  states: {state: disabled}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    dst_mac: '[0x30, 0x14, 0x4a, 0xe6, 0x46, 0xe4]'
    src_mac: '[0x12, 0x34, 0x56, 0x78, 0x90, 0xab]'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'True'
    log: 'False'
  states: {state: disabled}
- name: network_tuntap_pdu_0
  id: network_tuntap_pdu
  parameters:
    ifn: tap0
    istunflag: 'False'
    mtu: '440'
  states: {state: disabled}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '1234'
    src_zeros: 'False'
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: 48*10
    type: complex
  states: {state: disabled}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: freq
    dev_args: serial= 000000000000000026b468dc342a188f
    samp_rate: samp_rate
    type: fc32
    vga: tx_vga_gain
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: freq
    dev_args: serial= 0000000000000000b65c67dc321f3d5f
    gain: rx_if_gain
    samp_rate: samp_rate
    type: fc32
    vga: rx_vga_gain
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: samp_rate
    chan_est: ieee802_11.Equalizer(chan_est)
    encoding: ieee802_11.Encoding(encoding)
    frequency: freq
    sensitivity: sensitivity
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:52003
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:52002
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_0_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:52010
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_0_0_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:52011
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_0_0_1
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:52012
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_0_0_2
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:52013
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_0_0_2_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:52014
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_0_0_2_0_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:52015
    timeout: '100'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]
- [blocks_message_strobe_0, strobe, zeromq_pub_msg_sink_0, in]
- [blocks_multiply_const_vxx_0, '0', foo_packet_pad2_0, '0']
- [blocks_throttle_0, '0', wifi_phy_hier_0, '0']
- [blocks_var_to_msg_0, msgout, blocks_message_debug_0_0_0_0, print]
- [blocks_var_to_msg_0_0, msgout, blocks_message_debug_0_0_0_0, print]
- [blocks_var_to_msg_0_1, msgout, blocks_message_debug_0_0_0_0, print]
- [blocks_var_to_msg_0_2, msgout, blocks_message_debug_0_0_0_0, print]
- [blocks_var_to_msg_0_2_0, msgout, blocks_message_debug_0_0_0_0, print]
- [blocks_var_to_msg_0_2_0_0, msgout, blocks_message_debug_0_0_0_0, print]
- [foo_packet_pad2_0, '0', soapy_hackrf_sink_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_ether_encap_0, to tap, network_tuntap_pdu_0, pdus]
- [ieee802_11_ether_encap_0, to wifi, ieee802_11_mac_0, app in]
- [ieee802_11_mac_0, app out, blocks_message_debug_0, print]
- [ieee802_11_mac_0, app out, zeromq_pub_msg_sink_0, in]
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [network_tuntap_pdu_0, pdus, ieee802_11_ether_encap_0, from tap]
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', wifi_phy_hier_0, '0']
- [wifi_phy_hier_0, '0', blocks_multiply_const_vxx_0, '0']
- [wifi_phy_hier_0, '0', blocks_throttle_0, '0']
- [wifi_phy_hier_0, carrier, pdu_pdu_to_tagged_stream_0, pdus]
- [wifi_phy_hier_0, mac_out, foo_wireshark_connector_0, in]
- [wifi_phy_hier_0, mac_out, ieee802_11_ether_encap_0, from wifi]
- [wifi_phy_hier_0, mac_out, ieee802_11_mac_0, phy in]
- [wifi_phy_hier_0, mac_out, ieee802_11_parse_mac_0, in]
- [zeromq_sub_msg_source_0, out, blocks_message_debug_0_0, print]
- [zeromq_sub_msg_source_0, out, ieee802_11_mac_0, app in]
- [zeromq_sub_msg_source_0_0_0, out, blocks_message_debug_0_0_0_0, print]
- [zeromq_sub_msg_source_0_0_0, out, blocks_msgpair_to_var_0, inpair]
- [zeromq_sub_msg_source_0_0_0_0, out, blocks_message_debug_0_0_0_0, print]
- [zeromq_sub_msg_source_0_0_0_0, out, blocks_msgpair_to_var_0_0, inpair]
- [zeromq_sub_msg_source_0_0_0_1, out, blocks_msgpair_to_var_0_1, inpair]
- [zeromq_sub_msg_source_0_0_0_2, out, blocks_msgpair_to_var_0_2, inpair]
- [zeromq_sub_msg_source_0_0_0_2_0, out, blocks_msgpair_to_var_0_2_0, inpair]
- [zeromq_sub_msg_source_0_0_0_2_0_0, out, blocks_msgpair_to_var_0_2_0_0, inpair]

metadata:
  file_format: 1
