options:
  parameters:
    category: Custom
    description: 'The project tests functionalities for: (i) setting variable, (ii) message echoing.'
    generate_options: no_gui
    id: wifi_transceiver_patched
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2.412e09
  states: {}
- name: rx_if_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: rx_vga_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e06
  states: {}
- name: blocks_message_debug_0_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {}
- name: blocks_msgpair_to_var_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: rx_if_gain
  states: {}
- name: blocks_msgpair_to_var_0_1
  id: blocks_msgpair_to_var
  parameters:
    target: samp_rate
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: freq
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: rx_if_gain
    target: rx_if_gain
  states: {}
- name: blocks_var_to_msg_0_1
  id: blocks_var_to_msg
  parameters:
    msgname: samp_rate
    target: samp_rate
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:52003
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:52002
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_0_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:52010
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_0_0_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:52011
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_0_0_1
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:52012
    timeout: '100'
  states: {}

connections:
- [blocks_var_to_msg_0, msgout, blocks_message_debug_0_0_0_0, print]
- [blocks_var_to_msg_0_0, msgout, blocks_message_debug_0_0_0_0, print]
- [blocks_var_to_msg_0_1, msgout, blocks_message_debug_0_0_0_0, print]
- [zeromq_sub_msg_source_0, out, zeromq_pub_msg_sink_0, in]
- [zeromq_sub_msg_source_0_0_0, out, blocks_message_debug_0_0_0_0, print]
- [zeromq_sub_msg_source_0_0_0, out, blocks_msgpair_to_var_0, inpair]
- [zeromq_sub_msg_source_0_0_0_0, out, blocks_message_debug_0_0_0_0, print]
- [zeromq_sub_msg_source_0_0_0_0, out, blocks_msgpair_to_var_0_0, inpair]
- [zeromq_sub_msg_source_0_0_0_1, out, blocks_msgpair_to_var_0_1, inpair]

metadata:
  file_format: 1
